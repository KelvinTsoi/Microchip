# Keil uVision project STM32F105RBT6_PowerControl.uvprojx, settings and files
target STM32F105RBT6_PowerControl (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F105RBT6_PowerControl +hex
  AfterMake: fromelf.exe --bin  -o ../Obj/STM32F105RBT6_PowerControl.bin ../Obj/STM32F105RBT6_PowerControl.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,USE_USB_DEVICE_FS,STM32F072,INTERNAL_PULLUP,DEBUG
  c include: ..\Usr;..\Drive;..\Usr;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drive
    ../Drive/: delay.c uart.c relay.c tim.c keyboard.c
    ../Usr/: watchdog.c
  group Usr
    ../Usr/: main.c
